options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: cross-correlation
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_label
  parameters:
    type: real
    value: 900e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: fft_vxx_2
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
    ymax: '50'
    ymin: '-50'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: rtlsdr_source_1
  id: rtlsdr_source
  parameters:
    args: '"rtl=1"'
    bb_gain0: '20'
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_2, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_1, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_2, '0', blocks_complex_to_mag_0, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [rtlsdr_source_1, '0', blocks_stream_to_vector_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
