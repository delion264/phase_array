options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: cross-correlation
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_label
  parameters:
    type: int
    value: '250000'
  states: {}
- name: center_freq
  id: variable_qtgui_label
  parameters:
    type: real
    value: '100700000'
  states: {}
- name: fft_size
  id: variable_qtgui_label
  parameters:
    type: int
    value: '524288'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '61400000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/donny/phase_array/IQ_recordings/bladerf_sync0
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/donny/phase_array/IQ_recordings/bladerf_sync1
    type: complex
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_2
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=0
    bb_gain0: '20'
    bw0: bandwidth
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0_0
  id: osmosdr_source
  parameters:
    args: bladerf=1
    bb_gain0: '20'
    bw0: bandwidth
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    update_time: '0.001'
    vlen: fft_size
    x_start: '-250000'
    x_step: '1.0'
    ymax: '50'
    ymin: '-50'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_2, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_1, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_2, '0', blocks_complex_to_mag_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [osmosdr_source_0_0, '0', blocks_file_sink_0_0, '0']
- [osmosdr_source_0_0, '0', blocks_stream_to_vector_1, '0']

metadata:
  file_format: 1
