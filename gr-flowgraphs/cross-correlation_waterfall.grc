options:
  parameters:
    generate_options: qt_gui
    id: default
    output_language: python
    title: cross-correlation
  states: {}

blocks:
- name: bandwidth
  id: variable_qtgui_label
  parameters:
    type: int
    value: '50000'
  states: {}
- name: center_freq
  id: variable_qtgui_label
  parameters:
    type: int
    value: '937600000'
  states: {}
- name: fft_size
  id: variable_qtgui_label
  parameters:
    type: int
    value: '524288'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '40000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/donny/phase_array/IQ_recordings/bladerf_sync0
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/donny/phase_array/IQ_recordings/bladerf_sync1
    type: complex
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_size
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_1
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'True'
    nthreads: '2'
    shift: 'True'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {}
- name: fft_vxx_2
  id: fft_vxx
  parameters:
    fft_size: fft_size
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.blackmanharris(fft_size)
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"bladerf=0,nchan=2"'
    bb_gain0: '20'
    bb_gain1: '20'
    bw0: bandwidth
    corr1: '0'
    dc_offset_mode1: '0'
    freq0: center_freq
    freq1: 100e6
    gain0: '10'
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    iq_balance_mode1: '0'
    nchan: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '32000'
    color1: '1'
    fc: '0'
    fftsize: '32768'
    int_max: '200'
    int_min: '-200'
    type: complex
    update_time: '0.05'
  states: {}

connections:
- [blocks_multiply_conjugate_cc_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', fft_vxx_2, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_1, '0']
- [blocks_vector_to_stream_0, '0', qtgui_waterfall_sink_x_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_1, '0', blocks_multiply_conjugate_cc_0, '1']
- [fft_vxx_2, '0', blocks_vector_to_stream_0, '0']
- [osmosdr_source_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', blocks_stream_to_vector_0, '0']
- [osmosdr_source_0, '1', blocks_stream_to_vector_1, '0']

metadata:
  file_format: 1
